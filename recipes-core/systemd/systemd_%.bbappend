PACKAGECONFIG_remove = " \
    hibernate \
    sysvinit \
    timesyncd \
"
