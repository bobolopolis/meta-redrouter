PACKAGECONFIG += "zstd"
